# IAR project Project.ewp, settings and files
configuration PY32F072ExB_Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F072ExB Puya PY32F072ExB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072ExB
  ICCARM.CCIncludePath2: ..\..\..\Drivers\CMSIS\Device\PY32F072E\Include; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\PY32F072E_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f072exB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PY32F072Ex9_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F072Ex9 Puya PY32F072Ex9
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072Ex9
  ILINK.IlinkIcfFile: py32f072ex9_flash.icf
configuration PY32F072Ex8_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F072Ex8 Puya PY32F072Ex8
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072Ex8
  ILINK.IlinkIcfFile: py32f072ex8_flash.icf
configuration PY32F072Ex6_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: PY32F072Ex6 Puya PY32F072Ex6
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F072Ex6
  ILINK.IlinkIcfFile: py32f072ex6_flash.icf
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_py32f072e.c
  group Drivers/PY32F072E_HAL_Driver
    ../../../Drivers/PY32F072E_HAL_Driver/Src/: py32f072e_hal.c py32f072e_hal_cortex.c py32f072e_hal_dma.c py32f072e_hal_gpio.c py32f072e_hal_pwr.c py32f072e_hal_rcc.c py32f072e_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_py32f072exx.s
  group Example/User
    ../Src/: main.c py32f072e_hal_msp.c py32f072e_it.c
