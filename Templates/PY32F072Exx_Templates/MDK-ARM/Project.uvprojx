# Keil uVision project Project.uvprojx, settings and files
target PY32F072ExB_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F072ExB Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F072ExB
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F072E\Include;..\..\..\Drivers\PY32F072E_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ./: startup_py32f072exx.s
    ../Src/: system_py32f072e.c
  group Application/User
    ../Src/: main.c py32f072e_hal_msp.c py32f072e_it.c
  group Drivers/PY32F072E_HAL_Driver
    ../../../Drivers/PY32F072E_HAL_Driver/Src/: py32f072e_hal.c py32f072e_hal_cortex.c py32f072e_hal_dma.c py32f072e_hal_gpio.c py32f072e_hal_rcc.c py32f072e_hal_rcc_ex.c py32f072e_hal_pwr.c
  group Doc
    ../: readme.txt
target PY32F072Ex9_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072x9 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00018000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F072Ex9
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x18000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x3000
target PY32F072Ex8_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F072Ex8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x2000
target PY32F072Ex6_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072Ex6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F072Ex6
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 6.1.0
